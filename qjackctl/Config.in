## qjackctl/Config.in
```kconfig
config BR2_PACKAGE_QJACKCTL
	bool "qjackctl"
	help
	  Simple JACK control panel.
	  
	  https://github.com/rncbc/qjackctl
```
